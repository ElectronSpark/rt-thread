# Keil uVision project project.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: R7FA6M4AF Renesas
  pack: Renesas.RA_DFP.3.1.0
  cpu: CPUTYPE("Cortex-M33") FPU2 CLOCK(12000000) ELITTLE
  output: ra6m4 +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: SOC_R7FA6M4AF, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: ..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;drivers;drivers\config;..\..\components\finsh;.;..\..\include;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\none-gcc;..\..\examples\utest\testcases\kernel
  library: MicroLIB
  scatter file: .\script\fsp.scat
  group CPU
    ../../libcpu/arm/common/: showmem.c backtrace.c div0.c
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../components/drivers/misc/: rt_drv_pwm.c pin.c
    ../../components/drivers/serial/: serial_v2.c
    ../../components/drivers/src/: ringblk_buf.c waitqueue.c workqueue.c dataqueue.c ringbuffer.c completion.c pipe.c
  group Drivers
    drivers/: drv_common.c drv_pwm.c
    ./drivers/: drv_gpio.c drv_usart_v2.c
  group Finsh
    ../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../src/: timer.c idle.c object.c mem.c irq.c scheduler.c ipc.c device.c kservice.c thread.c clock.c components.c
  group libc
    ../../components/libc/compilers/common/: time.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c SConscript
software components: Flex Software:RA Configuration 1.0.0
